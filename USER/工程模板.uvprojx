# Keil uVision project 工程模板.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\TFT;..\HARDWARE\BEEP;..\HARDWARE\ADC;..\HARDWARE\WKUP;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\SD;..\HARDWARE\SRAM;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\USMART;..\TEXT;..\PICTURE;..\APP\inc;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lvgl_driver;..\GUI_APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TFT/: tft.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../GUI/lvgl_driver/: lv_port_disp.c
  group GUI_APP
    ../GUI_APP/: lv_img_test.c
    ../GUI_APP/IMG/: img_2233.c true_color.c true_color_chroma_keyed.c true_color_with_alpha.c
